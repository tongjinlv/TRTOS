# Keil uVision project Project.uvproj, settings and files
target TOS_BOOTLOADER (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\upload.exe  "$L@L.bin" "STM32Bin" "BOOT[V3.0].bin"
  c flags: OneElfS=1
  c define: TOS_BOOTLOADER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\GUI;..\Tools;..\FS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\TGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB;..\USB\JoystickUsb\USB;..\USB\JoystickUsb\STM32_USB-FS-Device_DriverV3.1.1\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StdPeriph_Driver
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/: stm32l1xx_it.c system_stm32l1xx.c
  group Startup
    ../Libraries/Startup/: startup_stm32l1xx_md.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/arm/: startup_stm32l1xx_hd.s startup_stm32l1xx_mdp.s
  group Doc
    ../Doc/: record.txt readme.txt
    ../: README.md
  group Board_Driver
    ../Driver/: GPIOL_Driver.c STM32L_CPU.c UsartL_Driver.c
  group Configs
    ../Configs/: Include.h Define.h Configs.h
  group Tos
    ../Tos/: Tos_Include.h LockCode.c Tos.c Tos_Device.c Tos_Mema.c Tos_timer.c tos_core_a.asm
  group Tools
    ../Tools/: DeBug.c ModBus.c Text.c CheakOut.c Operation.c StandardModBus.c AppConfig.c
  group FuncTask
    ../FuncTask/: Func_Face.c ComKeyBoard.c
  group Main
    ../USER/: Main.c
target BOARD_InsectV2 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\upload.exe  "$L@L.bin" "GeekInsect" "GeekInsect[遥控].bin"
  c flags: Optim=1 OneElfS=1
  c define: BOARD_InsectV2 USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\Libraries\STM32L1xx_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
