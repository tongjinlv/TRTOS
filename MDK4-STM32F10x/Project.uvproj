# Keil uVision project Project.uvproj, settings and files
target BOARD_TWOCAN (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TWOCAN
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\TGui;..\Tools;..\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\FuncTask;..\MGui;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: STM32LIB_Include.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
  group Startup
    ../Libraries/Startup/: startup_stm32f10x_hd.s startup_stm32f10x_cl.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group Doc
    ../Doc/: record.txt readme.txt
    ../: README.md
  group Board_Driver
    ../Driver/: SPI_Driver.c I2C_Driver.c Usart_Driver.c STM32_CPU.c GPIO_Driver.c
  group Configs
    ../Configs/: Include.h Define.h Configs.h
  group Tos
    ../Tos/: Tos_Include.h LockCode.c Tos.c Tos_Device.c Tos_Mema.c Tos_timer.c tos_core_a.asm
  group Tools
    ../Tools/: DeBug.c ModBus.c Text.c CheakOut.c Operation.c StandardModBus.c AppConfig.c
  group FuncTask
    ../FuncTask/: Func_Face.c ComKeyBoard.c
  group Main
    ../USER/: Main.c
target BOARD_LCD4_3 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_LCD4_3
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\GUI\MGui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_REALLY (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: RELEASE BOARD_REALLY
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\TGui;..\Tools;..\FS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB;..\GUI\TGui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_PDATRAN (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: RELEASE BOARD_PDATRAN
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\TGui;..\Tools;..\FS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_CenCtr;..\USER\Prj_Sensor;..\FuncTask;..\GUI;..\USER\Prj_PdaTran;..\USB;..\GUI\TGui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_PRAFIRE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_PRAFIRE
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\TGui;..\Tools;..\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\USER\Prj_Prafire;..\GUI\TGui;..\GUI\MGui;..\FS;..\FS\TQFS;..\GUI;..\USER\Prj_Prafire\USB;..\USB\JoystickUsb\STM32_USB-FS-Device_DriverV3.1.1\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_SENSOR (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_SENSOR
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\GUI;..\Tools;..\FS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\TGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB;..\USB\JoystickUsb\USB;..\USB\JoystickUsb\STM32_USB-FS-Device_DriverV3.1.1\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_TANK_Hand (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TANK_Hand
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS;..\FuncTask;..\GUI\TGui;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_TANK_Ctr (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TANK_Ctr
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_NJSIGDOT (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_NJSIGDOT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_TANK_Ctr1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TANK_Ctr1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_TANK_TestBoot (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TANK_Ctr
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_TS_Collect (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TS_Collect
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_CenCtr;..\USER\Prj_Sensor;..\FuncTask;..\GUI;..\USER\Prj_PdaTran;..\GUI\TGui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_WJ4_3 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_WJ4_3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_CAMERACTR (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_CAMERACTR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_RS485ANGLE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_RS485ANGLE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_CAMERAMOTR (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_CAMERAMOTR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_BLACKBOX (ARM-ADS)
  device: STM32F105R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x800FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_BLACKBOX
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_CAMERAMRC (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_CAMERAMRC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TOS_BOOTLOADER (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\upload.exe  "$L@L.bin" "STM32Bin" "BOOT[V3.0].bin"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: TOS_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_REMOTECONTROL (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_REMOTECONTROL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_TELECONTROL (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TELECONTROL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_TANK_CtrNew (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TANK_CtrNew
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_SKYBUS (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_SKYBUS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BOARD_TP500_New (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\upload.exe  "$L@L.bin" "STM32Bin" "TP500V2[终结版].bin"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TP500_New
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_TP502T (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\upload.exe  "$L@L.bin" "STM32Bin" "TP502_T[掉线重启].bin"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TP502T
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target IAP_Addr0x5000 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: IAP_Addr0x5000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4c00
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_GEEK_Bast (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_GEEK_Bast
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\USB\STM32_USB-FS-Device_Driver\inc;..\USER\Prj_Geek_Bast
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_BastJson (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_BastJson
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Configs;..\Boot;..\Tos;..\Tools;..\FS\TQFS;..\USER\Prj_4.3LCD;..\USER\Prj_CanBus;..\USER\Prj_Sensor;..\GUI\MGui;..\FuncTask;..\USER\Prj_Really;..\USER\Prj_PdaTran;..\USB\WHID;..\FS;..\GUI\TGui;..\GUI;..\USB\STM32_USB-FS-Device_Driver\inc;..\USER\Prj_Geek_Bast;..\Libraries\Lua
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_Lora (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_Lora
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_Insect (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\trtos.exe  "$L@L.bin" "GeekInsect" "GeekInsect[New].bin" "开发环境配套固件"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_Insect
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_TP401 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\Window Tools\upload.exe  "$L@L.bin" "STM32Bin" "TP401[New].bin"  "这是一个新设备测试中"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_TP401
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_MiniDTU (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_MiniDTU
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_USBLora (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_USBLora
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target BOARD_AirCleaner (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_AirCleaner
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BOARD_Lite (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BOARD_Lite
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
